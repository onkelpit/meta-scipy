PACKAGECONFIG:remove = "lapack"
PACKAGECONFIG:append = " openblas"
